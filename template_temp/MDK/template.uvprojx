# Keil uVision project template.uvprojx, settings and files
target template_Release (ARM-ADS)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.4.2.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: template
  c flags: Optim=1 OneElfS=1 uC99=1
  c include: ..\..\..\mcu\common;..\source;..\..\..\driver\inc;..\user
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32f005.s
    ../../../mcu/common/: system_hc32f005.c
  group source
    ../user/: user_sever.c
    ../source/: main.c
  group driver
    ../../../driver/src/: ddl.c interrupts_hc32f005.c clk.c gpio.c adc.c adt.c bt.c crc.c flash.c i2c.c lpm.c lvd.c pca.c reset.c spi.c trim.c uart.c vc.c wdt.c
  group LCD
    ../user/: lcd_Drive.c lcd12864.c menu_Frame.c misc.c
  group hardeware
    ../user/: beep.c CRC16.c dui.c key.c timer.c uart_sever.c user_uart.c user_flash.c
  group Image
    ../user/: oledpage.h oledfont.h
  group README
    ../: readme.txt
software components: CMSIS:CORE 4.1.0
